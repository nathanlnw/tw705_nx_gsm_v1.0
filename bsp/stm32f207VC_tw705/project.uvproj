# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F207VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rt_stm32f4_drv
  AfterMake: fromelf --bin --output=.\build\rt_stm32f4_drv.bin .\build\rt_stm32f4_drv.axf
  c flags: Optim=4 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,USE_USB_OTG_FS
  c include: .;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;applications;drivers;.\build;.\drivers\serial;.\drivers\include;.\drivers\include\drivers;.\app_712;.\app_712\gps;.\app_712\gsm;..\..\src;.\app_712\lcd;.\app_712\U4_485;.\app_712\protocol_808;.\app_712\HMI;.\app_712\rtc;.\drivers\include;.\app_712\dataflash;.\app_712\dataflash\SST25;.\app_712\printer;.\drivers\usb;..\..\components\dfs;..\..\components\dfs\include;..\..\components\dfs\src;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\elmfat\option;..\..\components\dfs\filesystems\romfs;.\drivers\usb;.\drivers\spi_TF;.\app_712\CAN;.\app_712\shakesensor;.\app_712\ICcard;.\STM32F2xx_Libraries\CMSIS;.\STM32F2xx_Libraries\STM32F2xx_StdPeriph_Driver\inc;.\STM32F2xx_Libraries\STM32F2xx_StdPeriph_Driver\src;.\STM32F2xx_Libraries\STM32_USB_OTG_Driver;.\STM32F2xx_Libraries\STM32_USB_HOST_Library;.\STM32F2xx_Libraries\CMSIS\ST\STM32F2xx\Include;.\STM32F2xx_Libraries\STM32_USB_HOST_Library\Class\MSC;.\STM32F2xx_Libraries\STM32_USB_HOST_Library\Core\inc;.\STM32F2xx_Libraries\STM32_USB_OTG_Driver\inc;.\STM32F2xx_Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\app_712\DrvData;..\..\components\dfs\filesystems\elmfat\option;.\drivers\spi_TF
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./app_712/: App_moduleConfig.h App_moduleConfig.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c
    ./drivers/: board.h vuart.h vuart.c
    ./drivers/spi_TF/: diskio_sd.c SPI_SD_driver.c SPI_SD_driver.h
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group gps_uart5
    ./app_712/gps/: gps.c gps.h
  group gsm_uart2
    ./app_712/gsm/: App_gsm.c App_gsm.h Device_gsm.c Device_gsm.h SMS.c SMS.h SMS_PDU.c SMS_PDU.h
  group 485_u4
    ./app_712/U4_485/: Device_485.c Device_485.h App_485.c App_485.h
  group protocol808
    ./app_712/protocol_808/: app_808.c app_808.h Device_808.c Device_808.h protocol_808.c protocol_808.h Sys_config.c Sys_config.h CRC.c CRC.h
  group HMI
    ./app_712/HMI/: app_hmi.c app_hmi.h
  group RTC
    ./app_712/rtc/: rtc.c rtc.h
  group Dataflash
    ./app_712/dataflash/SST25/: SST25VF.c SST25VF.h
    ./app_712/dataflash/: Flash_Oper.h DF_Oper.c DF_Oper.h Flash_Oper.c
  group USB_Host
    ./drivers/usb/: usb_bsp.c usb_conf.h usbh.c usbh_conf.h usbh_usr.c usbh_usr.h
  group FileSystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../components/dfs/filesystems/elmfat/: ff.c diskio.c
    ../../components/dfs/filesystems/elmfat/option/: cc936.c
  group USB_StdLibrary
    ./STM32F2xx_Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./STM32F2xx_Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ./STM32F2xx_Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group SPI_TF
    ./drivers/spi_TF/: spi_sd.c spi_sd.h
  group Printer
    ./app_712/printer/: Device_printer.c Device_printer.h rtdevice.h
    ../../components/drivers/src/: ringbuffer.c
  group CAN
    ./app_712/CAN/: Device_CAN.c Device_CAN.h Device_CAN2.h Device_CAN2.c
  group shakesensor
    ./app_712/shakesensor/: mma8451.c mma8451.h
  group Lcd
    ./app_712/lcd/: bmp.c lcd.c Menu_0_0_password.c Menu_0_1_License.c Menu_0_2_CarType.c Menu_0_loggingin.c Menu_1_Idle.c Menu_2_1_Status8.c Menu_2_3_CentreTextStor.c Menu_2_4_CarInfor.c Menu_2_6_Mileage.c Menu_2_7_RequestProgram.c Menu_2_8_DnsIpDisplay.c Menu_2_InforCheck.c Menu_3_1_CentreQuesSend.c Menu_3_2_FullorEmpty.c Menu_3_InforInteract.c Menu_4_1_pilao.c Menu_4_2_chaosu.c Menu_4_InforTirExspd.c Menu_7_CentreTextDisplay.c Menu_Include.c Menu_0_4_VIN.c Menu_0_5_Colour.c Menu_0_3_Sim.c Menu_6_SetInfor.c Menu_0_0_SpdType.c Menu_0_0_self-Checking.c bmp.h lcd.h Menu_1_menu.c Menu_2_5_Version.c Menu_3_4_DriverInfor.c Menu_3_5_Affair.c Menu_3_6_LogOut.c Menu_5_1_PulseCoefficient.c Menu_5_2_ExportData.c Menu_5_3_print.c Menu_5_4_ICcard.c Menu_5_5_CarInfor.c Menu_5_6_speedlog.c Menu_5_recorder.c Menu_Include.h SED1520.h Menu_TXT.c Menu_0_0_mode.c LCD_Driver.c
  group ICcard
    ./app_712/ICcard/: IC_card.c SLE4442.c
  group CONTEX_M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group STM32F2X_library
    ./STM32F2xx_Libraries/CMSIS/Include/: core_cm3.h
    ./STM32F2xx_Libraries/CMSIS/ST/STM32F2xx/Include/: stm32f2xx.h system_stm32f2xx.h
    ./STM32F2xx_Libraries/CMSIS/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ./STM32F2xx_Libraries/STM32F2xx_StdPeriph_Driver/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
    ./STM32F2xx_Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ./STM32F2xx_Libraries/CMSIS/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group DrvData
    ./app_712/DrvData/: GB19056.c GB19056.h vdr.c Vdr.h
